# Keil uVision project c_shell.uvprojx, settings and files
target c_shell (6160000::V6.16::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: c_shell
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=4
  c include: ..\..\..\..\..\c_shell
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group source
    ../../usr_app/: usr_app.c c_shell_commands.c
    ../../../../: c_shell.c c_shell.h c_shell_cfg.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H750VBTx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H750VBTx/STCubeGenerated/Inc/: stm32h7xx_it.h
  group bsp
    ../../bsp/: bsp.c
    ../../bsp/uart/: uart.c uart.h xhal_uart.h
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:USART 1.3.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:IRDA 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:Smartcard 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:STM32Cube HAL:USART 1.9.0, Device:Startup 1.9.0
